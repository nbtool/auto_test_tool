options:
  parameters:
    generate_options: no_gui
    id: gr_ble_adv_tx
    output_language: python
    title: gr_ble_adv_tx
  states: {}

blocks:
- name: channel
  id: variable
  parameters:
    value: '37'
  states: {}
- name: ll_datas
  id: variable
  parameters:
    value: cmp_ble.create_ll_payload(mac, adv_datas, channel)
  states: {state: disabled}
- name: phy_datas
  id: variable
  parameters:
    value: (0xaa, 0xd6, 0xbe, 0x89, 0x8e, 0xcf, 0xf2, 0x51, 0xa4, 0x39, 0xa4, 0x64, 0xb1, 0x6c, 0x38, 0x42, 0x0c, 0xc4, 0x58, 0xba, 0x8f, 0x33, 0x8c, 0xdf, 0xbf, 0xf1, 0x27, 0x5b, 0xf7, 0xf6, 0xf7, 0x7f, 0x0b, 0x8e, 0x55, 0x99, 0x03, 0xc4, 0x8d, 0xbd, 0x15, 0xf9)
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 4e6
  states: {}
- name: tx_freq
  id: variable
  parameters:
    value: '2402000000'
  states: {}
- name: blocks_char_to_float_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_char_to_float_0_0
  id: blocks_char_to_float
  parameters:
    scale: '1'
  states: {state: disabled}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    begin_tag: pmt.intern("Begin")
    file: normalization_sample.bin
    repeat: 'True'
    type: complex
  states: {}
- name: blocks_stream_mux_0
  id: blocks_stream_mux
  parameters:
    lengths: (1, 3)
    type: byte
  states: {state: disabled}
- name: blocks_stream_mux_0_0
  id: blocks_stream_mux
  parameters:
    lengths: (15, len(phy_datas)*8*4, 15)
    num_inputs: '3'
    type: byte
  states: {state: disabled}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: len(phy_datas)*8*4
    type: byte
  states: {state: disabled}
- name: blocks_throttle_0
  id: blocks_throttle
  parameters:
    samples_per_second: samp_rate
    type: complex
  states: {}
- name: blocks_unpack_k_bits_bb_0
  id: blocks_unpack_k_bits_bb
  parameters:
    k: '8'
  states: {state: disabled}
- name: blocks_vector_source_x_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: phy_datas
  states: {state: disabled}
- name: blocks_vector_source_x_1
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: (0, 0, 0)
  states: {state: disabled}
- name: blocks_vector_source_x_1_0_0
  id: blocks_vector_source_x
  parameters:
    repeat: 'True'
    type: byte
    vector: '[0]*15'
  states: {state: disabled}
- name: digital_burst_shaper_xx_0
  id: digital_burst_shaper_xx
  parameters:
    insert_phasing: 'False'
    length_tag_name: '"packet_len"'
    post_padding: '15'
    pre_padding: '15'
    type: float
    window: ([])
  states: {state: disabled}
- name: digital_map_bb_0
  id: digital_map_bb
  parameters:
    map: (-1,1)
  states: {state: disabled}
- name: qtgui_time_sink_x_1
  id: qtgui_time_sink_x
  parameters:
    size: (len(phy_datas)*8*4+15*2)*3
    srate: samp_rate
    type: float
  states: {state: disabled}
- name: rational_resampler_xxx_0
  id: rational_resampler_xxx
  parameters:
    decim: '1'
    interp: '1'
    type: ccc
  states: {state: disabled}
- name: rational_resampler_xxx_0_0
  id: rational_resampler_xxx
  parameters:
    decim: '4'
    fbw: '0.1'
    interp: '10'
    taps: ''
    type: ccc
  states: {}
- name: zeromq_pub_sink_0
  id: zeromq_pub_sink
  parameters:
    address: tcp://127.0.0.1:5557
    timeout: '100'
    type: complex
  states: {}

connections:
- [blocks_char_to_float_0, '0', digital_burst_shaper_xx_0, '0']
- [blocks_char_to_float_0_0, '0', qtgui_time_sink_x_1, '0']
- [blocks_file_source_0, '0', blocks_throttle_0, '0']
- [blocks_stream_mux_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_mux_0_0, '0', blocks_char_to_float_0_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', blocks_stream_mux_0_0, '1']
- [blocks_throttle_0, '0', rational_resampler_xxx_0_0, '0']
- [blocks_unpack_k_bits_bb_0, '0', digital_map_bb_0, '0']
- [blocks_vector_source_x_0, '0', blocks_unpack_k_bits_bb_0, '0']
- [blocks_vector_source_x_1, '0', blocks_stream_mux_0, '1']
- [blocks_vector_source_x_1_0_0, '0', blocks_stream_mux_0_0, '2']
- [digital_burst_shaper_xx_0, '0', qtgui_time_sink_x_1, '0']
- [digital_map_bb_0, '0', blocks_stream_mux_0, '0']
- [rational_resampler_xxx_0_0, '0', zeromq_pub_sink_0, '0']

metadata:
  file_format: 1
  grc_version: 3.10.12.0
